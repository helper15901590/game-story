# Keil uVision project Story_machine.uvproj, settings and files
target Story_machine (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Story_machine V1.0 +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\APP_Driver\KEY;..\APP_Driver\LED;..\APP_Driver\Main;..\APP_Driver\RC522;..\APP_Driver\Sleep;..\APP_Driver\WT2003
  asm include: ..\Library\StdDriver\inc;..\APP_Driver\Main;..\APP_Driver\KEY
  group Main
    ../APP_Driver/Main/: main.c
  group Common
    ../Library/StdDriver/src/: delay.c sys.c uart.c
    ../APP_Driver/Sleep/: Sleep.c
    ../APP_Driver/KEY/: Key.c
    ../APP_Driver/RC522/: RC522.c RC522_Function.c
    ../APP_Driver/LED/: LED.c
    ../APP_Driver/WT2003/: WT2003.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
